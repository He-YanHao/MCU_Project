# Keil uVision project GD32F470.uvprojx, settings and files
target GD32F470 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: GD32F450ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.3.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F470 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Firmware\GD32F4xx_standard_peripheral\Include;..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32F4xx\Include;..\User;..\Hardware\led
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: systick.c main.c gd32f4xx_it.c
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group Hardware
    ../Hardware/led/: bsp_led.c
    ../Hardware/RGB/: RGB.c RGB.h
  group Firmware
    ../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_gpio.c gd32f4xx_rcu.c gd32f4xx_i2c.c gd32f4xx_spi.c gd32f4xx_tli.c
  group Doc
    ../Doc/: readme.txt
