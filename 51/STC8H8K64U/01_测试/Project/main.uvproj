# Keil uVision project main.uvproj, settings and files
target Target_1 (MCS-51)
  device: AI8H8K64U Series AI
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\system
  group user
    ../user/: main.c
  group system
    ../system/: delay.c delay.h I2C.c I2C.h
