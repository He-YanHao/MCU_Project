# Keil uVision project STM32-DEMO.uvproj, settings and files
target MP3（SPI1）-DEMO (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32-DEMO +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\CMSIS;..\FWlib\inc;..\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ./: main.c stm32f10x_it.c sdcard.c diskio.c ff.c SysTick.c usart1.c vs1003.c
  group FWlib
    ../FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_sdio.c misc.c stm32f10x_dma.c stm32f10x_spi.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group DOC
    ../: readme.txt
